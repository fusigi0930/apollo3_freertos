# IAR project release.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMA3B1KK-KBR AmbiqMicro AMA3B1KK-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_PACKAGE_BGA; BUILD_IAR; PLATFORM_APOLLO3; AM_PART_APOLLO3; AM_FREERTOS
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\board\apollo3\vendor_sdk\bsp; ..\..\board\apollo3\vendor_sdk\CMSIS\AmbiqMicro\Include; ..\..\board\apollo3\vendor_sdk\CMSIS\ARM\Include; ..\..\board\apollo3\vendor_sdk\devices; ..\..\board\apollo3\vendor_sdk\mcu\apollo3; ..\..\board\apollo3\vendor_sdk\mcu\apollo3\hal; ..\..\board\apollo3\vendor_sdk\mcu\apollo3\regs; ..\..\board\apollo3\vendor_sdk\utils; ..\..\board\apollo3; ..\..\freertos\inc; ..\..\src
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: release.bin
  ILINK.IlinkOutputFile: release.out
  ILINK.IlinkIcfFile: ..\..\board\apollo3\vendor_sdk\other\iar\Apollo3.icf
  ILINK.IlinkAdditionalLibs: ..\..\board\apollo3\vendor_sdk\bsp\iar\libam_bsp.a; ..\..\board\apollo3\vendor_sdk\mcu\apollo3\hal\iar\libam_hal.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../src/: freertos_main.c
  group board
    ../../board/apollo3/vendor_sdk/devices/: am_devices_i2c.c
    ../../board/apollo3/vendor_sdk/utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
    ../../board/apollo3/: board_apollo3.c
    ../../board/apollo3/vendor_sdk/other/iar/: startup_iar.c
  group freertos
    ../../freertos/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../freertos/src/MemMang/: heap_3.c
  group mcu
    ../../board/apollo3/: port.c portasm.s
